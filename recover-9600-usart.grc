options:
  parameters:
    generate_options: qt_gui
    id: recover9600usart
    output_language: python
    title: sweeper
  states: {}

blocks:
- name: carrier_default
  id: variable
  parameters:
    value: '2493524739'
  states: {}
- name: carrier_freq
  id: variable_qtgui_range
  parameters:
    label: frequency
    orient: Qt.Horizontal
    rangeType: int
    start: '2400000000'
    step: '3'
    stop: '2500000000'
    value: carrier_default
  states: {}
- name: rx_gain_var
  id: variable_qtgui_range
  parameters:
    label: rx gain
    min_len: '50'
    orient: Qt.Horizontal
    rangeType: int
    start: '10'
    step: '1'
    stop: '45'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: square_test_freq
  id: variable_qtgui_entry
  parameters:
    label: Test Wave Frequency
    type: int
    value: '7000'
  states: {}
- name: tx_gain_var
  id: variable_qtgui_range
  parameters:
    label: tx gain
    min_len: '50'
    orient: Qt.Horizontal
    rangeType: int
    start: '10'
    step: '1'
    stop: '45'
    value: '40'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1'
    offset: '0'
    phase: '0'
    samp_rate: '10000'
    type: complex
    waveform: analog.GR_SQR_WAVE
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/savra/radio-stuff/usart-out.bin
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '40'
    type: float
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '30'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '50'
    init: '0'
    low: '0'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '100'
    long_form: 'True'
    type: ff
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    alias: LPF - 10k Square
    cutoff_freq: '9600'
    decim: '25'
    gain: '1024'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '512'
    win: firdes.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: 'Good frequency, desk: 2420Mhz'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    bw0: '5000000'
    freq0: carrier_freq
    gain0: tx_gain_var
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    bw0: '5000000'
    freq0: carrier_freq
    gain0: rx_gain_var
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '4024'
    srate: samp_rate
    type: float
    update_time: '0.1'
    ymax: '-200'
    ymin: '200'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '4024'
    srate: samp_rate
    type: float
    update_time: '0.1'
    ymax: '-200'
    ymin: '200'
  states: {}

connections:
- [analog_const_source_x_0, '0', osmosdr_sink_0, '0']
- [analog_sig_source_x_0, '0', osmosdr_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', dc_blocker_xx_0, '0']
- [blocks_float_to_char_0, '0', blocks_file_sink_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_float_to_char_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_threshold_ff_0, '0']
- [blocks_threshold_ff_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0, '0']
- [dc_blocker_xx_0, '0', blocks_moving_average_xx_0, '0']
- [dc_blocker_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [dc_blocker_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
