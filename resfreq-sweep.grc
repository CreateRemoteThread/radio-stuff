options:
  parameters:
    generate_options: qt_gui
    id: chipenable
    output_language: python
    title: sweeper
  states: {}

blocks:
- name: carrier_freq
  id: variable_qtgui_range
  parameters:
    label: frequency
    orient: Qt.Horizontal
    rangeType: int
    start: '2400000000'
    step: '3'
    stop: '2500000000'
    value: '2450000000'
  states: {}
- name: carrier_freq2
  id: variable
  parameters:
    value: '2465000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '5000000'
  states: {}
- name: square_test_freq
  id: variable_qtgui_entry
  parameters:
    label: Test Wave Frequency
    type: int
    value: '5000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1'
    offset: '0'
    phase: '0'
    samp_rate: square_test_freq
    type: complex
    waveform: analog.GR_SQR_WAVE
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '128'
    type: float
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '300000'
    decim: '100'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    bw0: '3000000'
    freq0: carrier_freq
    gain0: '20'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    bw0: '3000000'
    freq0: carrier_freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: '300000'
    type: float
  states: {}

connections:
- [analog_const_source_x_0, '0', osmosdr_sink_0, '0']
- [analog_sig_source_x_0, '0', osmosdr_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [dc_blocker_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [low_pass_filter_0, '0', dc_blocker_xx_0, '0']
- [osmosdr_source_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
